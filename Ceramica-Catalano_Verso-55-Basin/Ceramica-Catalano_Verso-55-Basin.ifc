Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Ceramica-Catalano_Verso-55-Basin.ifc
Time: 2020-06-15T16:54:07
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Verso 55 Basin
ePset_BIMobjectScript - ACCESSORIES: NONE; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Verso 55 Basin; SKU (BO_prodsku): catalano_basin_verso_55_cod_15535zp00; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_basin_verso_55_cod_15535zp00; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_basin_verso_55_cod_15535zp00; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Fireclay; IfcClassification (BO_ifcclas): Sanitary Terminal; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
